# Keil uVision project breeze_firmware_none.uvprojx, settings and files
target breeze_firmware_none (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: breeze_firmware_none +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\User;..\Drivers\Driver_Sys;..\Drivers\Driver_IIC;..\Drivers\Driver_Tim;..\Drivers\Driver_SPI;..\Drivers\Driver_Flash;..\Drivers\Driver_PWM;..\Drivers\Driver_Delay;..\Drivers\Driver_USART;..\Drivers\Driver_EEPROM;..\System\System_Led;..\System\System_Battery;..\System\System_Monitor;..\System\System_RPData;..\System\System_MS5611;..\System\System_MPU6050;..\System\System_NRF24L01;..\Algorithm\Algorithm_IMU;..\Algorithm\Algorithm_BAR;..\Algorithm\Algorithm_Filter;..\Algorithm\Algorithm_Flight;..\Algorithm\Algorithm_Control;..\Libraries\FWLib\inc;..\Libraries\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLib
    ../Libraries/FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: main.c stm32f10x_it.c
  group Drivers
    ../Drivers/Driver_Sys/: stm32f10x_driver_sys.c
    ../Drivers/Driver_IIC/: stm32f10x_driver_iic.c
    ../Drivers/Driver_SPI/: stm32f10x_driver_spi.c
    ../Drivers/Driver_Tim/: stm32f10x_driver_tim.c
    ../Drivers/Driver_PWM/: stm32f10x_driver_pwm.c
    ../Drivers/Driver_Flash/: stm32f10x_driver_flash.c
    ../Drivers/Driver_USART/: stm32f10x_driver_usart.c
    ../Drivers/Driver_Delay/: stm32f10x_driver_delay.c
    ../Drivers/Driver_EEPROM/: stm32f10x_driver_eeprom.c
  group System
    ../System/System_Led/: stm32f10x_system_led.c
    ../System/System_Battery/: stm32f10x_system_battery.c
    ../System/System_RPData/: stm32f10x_system_rpdata.c
    ../System/System_Monitor/: stm32f10x_system_monitor.c
    ../System/System_MS5611/: stm32f10x_system_ms5611.c
    ../System/System_NRF24L01/: stm32f10x_system_nrf24l01.c
    ../System/System_MPU6050/: stm32f10x_system_mpu6050.c
  group Algorithm
    ../Algorithm/Algorithm_IMU/: stm32f10x_algorithm_imu.c
    ../Algorithm/Algorithm_BAR/: stm32f10x_algorithm_bar.c
    ../Algorithm/Algorithm_Filter/: stm32f10x_algorithm_filter.c
    ../Algorithm/Algorithm_Flight/: stm32f10x_algorithm_flight.c
    ../Algorithm/Algorithm_Control/: stm32f10x_algorithm_control.c
